# Repository Newsunking/Custom_motordriver

## KiCad design a3921kaitaku.kicad_pcb

Parts:
C1: C; C_Disc_D9.0mm_W5.0mm_P7.50mm
C2: 0.47μF; C_0603_1608Metric
C3, C4: 2.4μF; C_0603_1608Metric
C5, C6, C7, C9, C12, C13, C14, C15, C16, C18: 0.1μF; C_0603_1608Metric
C8: 22μF; C_0603_1608Metric
C10, C11: 22pF; C_0603_1608Metric
C17: 4.7μF; C_0603_1608Metric
D1, D2, D3, D4: LED; LED_D3.0mm
D5, D6, D7, D8, D9: D; D_1206_3216Metric
IC1: A3921KLPTR-T; A3944KLPTRT; Manufacturer_Part_Number A3921KLPTR-T; Mouser Part Number 250-A3921KLPTR-T
J1: STlink; PinHeader_1x06_P2.54mm_Vertical
J2: UARTport; PinHeader_1x03_P2.54mm_Vertical
J3, J4: Conn_01x02_Pin; PinHeader_1x02_P2.54mm_Horizontal
M1: Motor_DC; Amass_XT60PW-M
Q1: Q1H; TO-252-2
Q2: Q2H; TO-252-2
Q3: Q1L; TO-252-2
Q4: Q2L; TO-252-2
QFF1, QFF2: NPN; SOT-23
QRESET1: NPN; SOT-23
R1: 9.1kΩ; R_1206_3216Metric
R2, R4, R19, R20: 47kΩ; R_1206_3216Metric
R3, R5, R6, R9, R13, R14: 1kΩ; R_1206_3216Metric
R7, R8, R10, R11, R12: 10kΩ; R_1206_3216Metric
R15, R16, R17, R18: 22Ω; R_1206_3216Metric
R21: 330kΩ; R_1206_3216Metric
R22: 300Ω; R_1206_3216Metric
R23, R24: 60Ω; R_1206_3216Metric
R25: 100kΩ; R_1206_3216Metric
SW1: SW_DIP_x02; SW_DIP_SPSTx02_Slide_9.78x7.26mm_W7.62mm_P2.54mm
U1: Si8640BA-B-IU; QSOP-16_3.9x4.9mm_P0.635mm
U2: STM32F303K8Tx; LQFP-32_7x7mm_P0.8mm
U3: LF33_TO252; TO-252-2
U4: MCP2561-E-SN; DIP-8_W7.62mm
U5: LF50_TO252; TO-252-2
XT1, XT2: Amass_XT60PW-M
Y1: 48MHz; Crystal_HC49-U_Vertical

Connections:
+5V: C18.1, U4.3 (VDD), U5.3 (VO)
+12V: U3.1 (VI), U5.1 (VI), XT2.2
BOOT0: R12.1, U2.31 (BOOT0)
CA: C3.1, IC1.9 (CA)
CANH: J3.2, J4.2, SW1.2, U4.6 (CANL)
CANL: J3.1, J4.1, SW1.1, U4.7 (CANH)
CB: C4.1, IC1.6 (CB)
CP1: C2.2, IC1.16 (CP1)
CP2: C2.1, IC1.15 (CP2)
FF1: IC1.25 (FF1), R8.1, R14.2
FF2: IC1.26 (FF2), R7.2, R13.2
GHA: IC1.10 (GHA), R16.1
GHB: IC1.5 (GHB), R15.2
GLA: IC1.12 (GLA), R18.1
GLB: IC1.3 (GLB), R17.2
GND: C1.2, C5.2, C6.2, C7.2, C8.2, C16.1, D1.1 (K), D8.2 (A), D9.2 (A), IC1.2 (LSS), IC1.17 (GND), Q3.3 (S), Q4.3 (S), QFF1.3 (E), QFF2.3 (E), QRESET1.3 (E), R1.1, R10.2, R19.2, R20.2, U1.9 (GND2), U1.15 (GND2), XT1.1
GND1: C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C17.2, C18.2, D4.1 (K), J1.3, J2.3, R12.2, R25.1, U1.2 (GND1), U1.8 (GND1), U2.16 (VSS), U2.32 (VSS), U3.2 (GND), U4.2 (VSS), U5.2 (GND), XT2.1
NRST: C9.1, J1.5, R11.2, U2.4 (NRST)
unnamed: C17.1, R22.2, R23.2, R24.2
unnamed: D1.2 (A), R3.2
unnamed: D2.2 (A), R5.2
unnamed: D2.1 (K), QFF1.1 (C)
unnamed: D3.2 (A), R6.2
unnamed: D3.1 (K), QFF2.1 (C)
unnamed: D4.2 (A), R21.1
unnamed: D5.1 (K), IC1.13 (VBB)
unnamed: Q1.1 (G), R4.1, R16.2
unnamed: Q2.1 (G), R2.1, R15.1
unnamed: Q3.1 (G), R18.2, R19.1
unnamed: Q4.1 (G), R17.1, R20.1
unnamed: QFF1.2 (B), R8.2
unnamed: QFF2.2 (B), R7.1
unnamed: R23.1, SW1.3
unnamed: R24.1, SW1.4
unnamed: R25.2, U4.8 (STBY)
PA5: U1.3 (A1), U2.11 (PA5)
PA6: QRESET1.2 (B), U2.12 (PA6)
PA7: U1.4 (A2), U2.13 (PA7)
PA8: U1.6 (A4), U2.18 (PA8)
PA9: U1.5 (A3), U2.19 (PA9)
PA11: U2.21 (PA11), U4.4 (RXD)
PA12: U2.22 (PA12), U4.1 (TXD)
PA13: J1.4, U2.23 (PA13)
PA14: J1.2, U2.24 (PA14)
PB3: J1.6, U2.26 (PB3)
PB4: U2.27 (PB4)
PB7: R21.2, U2.30 (PB7)
PF0: C10.1, U2.2 (PF0), Y1.1
PF1: C11.1, U2.3 (PF1), Y1.2
PHASE: IC1.19 (PHASE), U1.14 (B1)
PWMH: IC1.23 (PWMH), U1.11 (B4)
PWML: IC1.22 (PWML), U1.12 (B3)
RDEAD: IC1.27 (RDEAD), R1.2
RESET: IC1.24 (RESET), QRESET1.1 (C)
RX: J2.2, U2.10 (PA4)
SA: C3.2, D6.2 (A), D8.1 (K), IC1.11 (SA), M1.2 (-), Q1.3 (S), Q3.2 (D), R4.2
SB: C4.2, D7.2 (A), D9.1 (K), IC1.4 (SB), M1.1 (+), Q2.3 (S), Q4.2 (D), R2.2
SPLIT: R22.1, U4.5 (SPLIT)
SR: IC1.21 (SR), U1.13 (B2)
TX: J2.1, U2.9 (PA3)
V5: C5.1, IC1.20 (V5), R5.1, R6.1, R9.1, R13.1, R14.1
VDD2: C12.1, C13.1, C14.1, C15.1, J1.1, R11.1, U1.1 (VDD1), U2.1 (VDD), U2.5 (VDDA), U2.17 (VDD), U3.3 (VO)
VDSTH: IC1.28 (VDSTH), R9.2, R10.1
VREG: C6.1, C8.1, IC1.8 (VREG)
drain: C1.1, C7.1, C16.2, D5.2 (A), D6.1 (K), D7.1 (K), IC1.1 (VDRAIN), Q1.2 (D), Q2.2 (D), R3.1, U1.16 (VDD2), XT1.2

Notes on the sheet:
マイコン
コネクタ
パスコン
アイソレータ
故障確認LED
CANトランシーバ
モータ駆動部

Board: 2 copper layers, 100.0 x 80.0 mm, 74 parts (0 on the bottom side), 64 nets.

## Commit log

2024-03-22 unchi
2024-03-23 korosuzo
2024-03-25 unti
2024-04-04 unchiunchi
